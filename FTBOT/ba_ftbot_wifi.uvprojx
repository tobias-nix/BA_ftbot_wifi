# Keil uVision project ba_ftbot_wifi.uvprojx, settings and files
target Uni (6180000::V6.18::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: ba_ftbot_wifi
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: wifi_uart_nix=huart6 HAL_CRC_MODULE_ENABLED
  c include: .\Includes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\e4EmbSys746.sct
  group Mains
    ./Source/: wifiMain.c wifiConfig.h common.h wifiMain.h
  group Init
    ./Source/: initCom.c initCom.h
  group Transmit
    ./Source/: transmitThread.c potiCalc.c potentiometerVoltage.c transmitThread.h
  group Receive
    ./Source/: receiveThread.c receiveInit.c receive.h
  group Drive
    ./Source/: driveThread.c driveGetterSetter.c driveThread.h
  group PB
    ./Source/: ftbot.pb.c pb_common.c pb_decode.c pb_encode.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Inc/: stm32f7xx_it.h
target Home (6220000::V6.22::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: as above
  output: ba_ftbot_wifi
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: wifi_uart_nix=huart2 HOMEOFFICE
  c include: .\Includes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Source\e4EmbSys746.sct
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:OS Interface:CMSIS-RTOS2 2.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, ETTI4 FTbot:EmbSysLab:FTbotLib 1.4.0, ETTI4 FTbot:EmbSysLab 1.4.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:ADC 1.3.0, Device:STM32Cube HAL:CRC 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:TIM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:STM32Cube LL:CRC 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.5
